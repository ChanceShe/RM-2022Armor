# Keil uVision project ARMOR.uvprojx, settings and files
target ARMOR (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ARMOR +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\USER;.\CORE;.\STM32F10x_FWLib\inc;.\STM32F10x_FWLib;.\RMLib;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\timer;.\SYSTEM\usart;.\HARDWARE\LED;.\HARDWARE\KEY;.\HARDWARE\HX711;.\HARDWARE\output2vs;.\TASK\controltask
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
    ./: README.TXT
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/HX711/: HX711.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/timer/: timer.c
  group TASK
    ./TASK/controltask/: controltask.c
  group STLIB
    ./STM32F10x_FWLib/: core_cm3.c startup_stm32f10x_hd.s
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_can.c
